# Keil uVision project lab1.uvproj, settings and files
target ST7735 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: ST7735
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: ST7735TestMain.c
    ../LiuWareTM4C123Lab3/: Filter.c IDQueue.c Interpreter.c JimString.c LEDS.c OS.c PFEdgeTrigger.c PLL.c ST7735.c SysTickInts.c ThreadPriorityPQueue.c Timer0A.c Timer1.c Timer3.c Timer5.c UART.c ADC.c startup.s PID_stm32.s osasm.s cr4_fft_64_stm32.s
    ../LiuWareTM4C123Lab3/CAN/: can.c can0.c interrupt.c Timer4.c
